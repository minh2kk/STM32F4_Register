# Keil uVision project STM32F407VET6.uvprojx, settings and files
target STM32F407VET6 (6140000::V6.14::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407VET6 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\User\Inc;..\Libraries\Inc
  asm include: ..\User;..\Libraries\Inc;..\StartUp
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Libraries
    ../Libraries/Inc/: rcc.h
  group User
    ../User/: main.c
  group StartUp
    ../StartUp/: startup_stm32f40xx.s
